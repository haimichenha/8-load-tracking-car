# Keil uVision project Target1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F101C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Target1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\JKXie\程序源码\STM32Project-无注释版\2-1 STM32工程模板\Start;.\User;.\Library;.\System;.\Hardware;.\softwork\EightWayTrack\BSP;.\softwork\EightWayTrack\CMSIS;.\softwork\EightWayTrack\FWLib;.\softwork\EightWayTrack\OBJ;.\softwork\EightWayTrack\BSP\Motor;.\softwork\EightWayTrack\BSP\TIMER;.\softwork\EightWayTrack\BSP\UART;.\softwork\STM32Core_SDK_IIC\Source\Drive;.\softwork\STM32Core_SDK_IIC\Source\wit_c_sdk
  asm define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ./softwork/EightWayTrack/USER/: AllHeader.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h mpu6050.c MPU6050_I2C.c Tracking.c Tracking.h app_irtracking.h app_motor.h bsp.h bsp_common.h bsp_motor_iic.h bsp_timer.h bsp_usart.h DHT11.h HCSR04.h IOI2C.h JY301P.h Motor.h mpu6050.h MPU6050_I2C.h app_irtracking.c app_motor.c app_usart.c app_usart.h bsp.c bsp_motor_iic.c bsp_timer.c bsp_usart.c DHT11.c HCSR04.c IOI2C.c JY301P.c Motor.c MyI2C.c MyI2C.h HW_I2C.c HW_I2C.h app_stats.c app_stats.h app_ui.c app_ui.h bsp_key.c bsp_key.h
    ./softwork/STM32Core_SDK_IIC/Source/Drive/: REG.h UART1.h UART2.h
    ./softwork/STM32Core_SDK_IIC/Source/wit_c_sdk/: wit_c_sdk.c wit_c_sdk.h
  group Start
    ../JKXie/程序源码/STM32Project-无注释版/2-1 STM32工程模板/Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
